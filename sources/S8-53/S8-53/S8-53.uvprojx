# Keil uVision project S8-53.uvprojx, settings and files
target S8-53 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F207ZCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: S8-53
  AfterMake: fromelf --bin --output .\s8-53.bin .\Objects\s8-53.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F207xx, __cplusplus
  c misc: --cpp
  c include: ..\STM32Cube_FW_F2\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\STM32Cube_FW_F2\Drivers\STM32F2xx_HAL_Driver\Inc;..\STM32Cube_FW_F2\Drivers\STM32F2xx_HAL_Driver\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src\include;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\system;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src\include\ipv4;..\STM32Cube_FW_F2\Middlewares\Third_Party\FatFs\src;..\STM32Cube_FW_F2\Middlewares\Third_Party\FatFs\src\drivers;.\src;.\src\libs;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src\include\lwip;..\STM32Cube_FW_F2\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group HAL
    ../STM32Cube_FW_F2/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_usb.c stm32f2xx_hal_hcd.c
    ../STM32Cube_FW_F2/Drivers/STM32F2xx_HAL_Driver/Inc/: stm32f2xx_hal_crc.h
  group libs
    ./src/libs/: stm32f2xx_it.h startup_stm32f207xx.s system_stm32f2xx.c stm32f2xx_hal_conf.h usbh_conf.h usbd_cdc_interface.h usbd_conf.h usbd_desc.h usbd_cdc_interface.cpp stm32f2xx_it.cpp usbd_conf.cpp stm32f2xx_hal_msp.cpp usbd_desc.cpp
  group src
    ./src/: main.h defines.h Globals.h main2.s Log.h main.cpp defines.cpp Globals.cpp Log.cpp
  group Hardware
    ./src/Hardware/: Hardware.h Timer.h Hardware.cpp Timer.cpp
  group VCP
    ./src/VCP/: VCP.h VCP.cpp
  group USBD
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
